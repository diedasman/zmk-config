## boards/shields/protomidiv1/Kconfig.defconfig
```kconfig
if SHIELD_PROTOMIDIV1

config ZMK_KEYBOARD_NAME
    default "protoMIDI"

endif # SHIELD_PROTOMIDIV1
```
